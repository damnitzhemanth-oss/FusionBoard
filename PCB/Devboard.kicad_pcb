# Repository damnitzhemanth-oss/FusionBoard (continued)

## KiCad design PCB/Devboard.kicad_pcb (continued)

Schematic: 04c_Zynq_PS_Perhipherals.kicad_sch

Parts:
C341, C343, C345, C347, C349, C351, C354, C356, C358, C360, C362, C363, C364, C365, C366, C367, C371, C374, C376, C377, C378, C379, C384, C386, C387, C388, C389, C390, C397, C399, C401, C402, C403, C405, C406, C407, C410, C411, C504: 0.1uF; C_0402_1005Metric
C342, C344, C346, C348, C350, C352, C353, C355, C357, C359, C361, C391, C393, C394, C395, C396, C398, C400, C404: 1uF; C_0402_1005Metric
C368, C369, C370, C380, C381, C382, C383, C392: 1nF; C_0402_1005Metric
C372, C373, C408, C409: 33pF; C_0402_1005Metric
C375, C385: 22uF; C_0402_1005Metric
Card1: TF-01A; TF-SMD_TF-01A; MPN TF-01A; LCSC Part C91145
FB9: BLM18; L_01005_0402Metric
J1: HR911105A_C12074; RJ45-TH_HR911105A; MPN HR911105A; LCSC Part C12074
J3: USB3_B; JST_SH_BM09B-SRSS-TB_1x09-1MP_P1.00mm_Vertical
J6: 3.3V_I2C; PinHeader_1x02_P2.54mm_Vertical
J10: Conn_02x07_Odd_Even; PinHeader_2x07_P2.54mm_Vertical
J11: Conn_01x04_Pin; PinHeader_1x04_P2.54mm_Vertical
R110, R112, R122, R125, R126, R127, R128, R133, R134, R136, R139: 22Ω; R_0402_1005Metric
R111, R113, R114, R115, R116, R117, R118, R119, R120, R121, R123, R130, R131, R141, R143, R151, R158, R162, R198: 10kΩ; R_0402_1005Metric
R124: 11kΩ; R_0402_1005Metric
R129, R132: 470Ω; R_0402_1005Metric
R135, R138: 5.1kΩ; R_0402_1005Metric
R137: 8.06kΩ; R_0402_1005Metric
R140, R145: 1kΩ; R_0402_1005Metric
R142, R144: 2.49kΩ; R_0402_1005Metric
R146: 47.5kΩ; R_0402_1005Metric
R147: 22.1kΩ; R_0402_1005Metric
R148: 1MΩ; R_0402_1005Metric
R149, R150, R152, R156, R157, R159, R160, R199, R200: 2.2kΩ; R_0402_1005Metric
R153, R155: 100kΩ; R_0402_1005Metric
R154: 200kΩ; R_0402_1005Metric
R161: 12kΩ; R_0402_1005Metric
U28: TXS02612RTWR; WQFN-24_L4.0-W4.0-P0.50-TL-EP2.5; MPN TXS02612RTWR; LCSC Part C140276
U29: MT25QU256ABA8ESF-0SIT TR; SOP-16_L10.3-W7.5-P1.27-LS10.4-BL; MPN MT25QU256ABA8ESF-0SIT; LCSC Part C2061781
U30: FEMDNN032G-A3A55; FBGA-153_L13.0-W11.5-P0.50_KLMAG1JETD-B041; MPN FEMDNN032G-A3A55; LCSC Part C5117593
U31: DP83867IRRGZR; VQFN-48_L7.0-W7.0-P0.50-TL-EP4.1; MPN DP83867IRRGZR; LCSC Part C2678038
U32: CP2102N-A02-GQFN24; QFN-24-1EP_4x4mm_P0.5mm_EP2.6x2.6mm
U33: USB3320C-EZK-TR; QFN-32_L5.0-W5.0-P0.50-BL-EP3.4; MPN USB3320C-EZK-TR; LCSC Part C132156
U34: TPD4E05U06DQA; USON-10_2.5x1.0mm_P0.5mm
U35, U53: TCA9548APWR; TSSOP-24_4.4x7.8mm_P0.65mm
U36: TXB0108PW; TSSOP-20_4.4x6.5mm_P0.65mm
U37: PCA9306; VSSOP-8_2.3x2mm_P0.5mm
U38: USB2514B_Bi; QFN-36-1EP_6x6mm_P0.5mm_EP3.7x3.7mm
USB2: TYPE-C-24P-SMD; USB-C-SMD_TYPE-C-24P-SMD; MPN TYPE-C-24P-SMD; LCSC Part C53207146
Y1, Y2: 25 MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm
Y3: 26 MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+1V2: C376.2, C377.2, C378.2, C379.2, C380.1, C381.1, C382.1, C383.1, U31.6 (VDD1P0), U31.24 (VDD1P0), U31.31 (VDD1P0), U31.42 (VDD1P0); also elsewhere on the board
+1V8: C360.1, C362.1, C365.2, C366.2, C367.2, C368.1, C369.1, C370.1, C384.1, C386.1, C387.1, C388.1, C397.1, C403.1, C407.1, C504.1, R111.1, R113.1, R114.1, R115.1, R116.1, R123.1, R130.1, R131.1, R141.1, R143.1, R149.1, R150.1, R151.1, R198.1, R199.1, R200.1, U28.5 (VCCA), U29.2 (VCC), U30.C6 (VCCQ), U30.M4 (VCCQ), U30.N4 (VCCQ), U30.P3 (VCCQ), U30.P5 (VCCQ), U31.19 (VDDIO), U31.30 (VDDIO), U31.41 (VDDIO), U32.5 (VIO), U33.28 (VDD18), U33.30 (VDD18), U33.32 (VDDIO), U35.1 (A0), U35.2 (A1), U35.21 (A2), U35.24 (VCC), U36.2 (V_{CCA}), U37.2 (VREF1), U53.1 (A0), U53.2 (A1), U53.21 (A2), U53.24 (VCC); also elsewhere on the board
+3V3: C341.2, C342.2, C343.2, C344.2, C345.2, C346.2, C347.2, C348.2, C349.2, C350.2, C351.2, C352.2, C353.1, C354.2, C355.2, C356.2, C357.2, C358.2, C359.2, C363.2, C364.2, C389.1, C393.1, C394.1, C395.2, C396.2, C398.2, C399.2, C400.2, C401.2, C402.1, C404.2, C405.2, C406.1, Card1.4 (VDD), FB9.1, J10.2, R117.1, R118.1, R119.1, R120.1, R121.1, R145.1, R154.1, R154.2, R156.1, R157.1, R159.1, R160.1, R162.1, U28.17 (VCCB1), U28.21 (VCCB0), U30.E6 (VCC), U30.F5 (VCC), U30.J10 (VCC), U30.K9 (VCC), U32.6 (VDD), U33.21 (VBAT), U36.19 (V_{CCB}), U37.7 (VREF2), U37.8 (EN), U38.15 (VDD33), U38.23 (VDD33); also elsewhere on the board
+5V_SYS: C391.2, J11.2, U32.7 (VREGIN); also elsewhere on the board
/Zynq Section/Peripherals/CC1: R135.1, USB2.A5 (CC1)
/Zynq Section/Peripherals/CC2: R138.1, USB2.B5 (CC2)
/Zynq Section/Peripherals/CMDB0: Card1.3 (CMD(DI)), R117.2, U28.20 (CMDB0)
/Zynq Section/Peripherals/DAT0B0: Card1.7 (DAT0(D0)), R118.2, U28.18 (DAT0B0)
/Zynq Section/Peripherals/DAT1B0: Card1.8 (DAT1(RSV)), R119.2, U28.16 (DAT1B0)
/Zynq Section/Peripherals/DAT2B0: Card1.1 (DAT2(RSV)), R120.2, U28.23 (DAT2B0)
/Zynq Section/Peripherals/DAT3B0: Card1.2 (CDDAT3(CS)), R121.2, U28.22 (DAT3B0)
/Zynq Section/Peripherals/DN1: U33.19 (DM), U38.30 (USBDM_UP)
/Zynq Section/Peripherals/DP1: U33.18 (DP), U38.31 (USBDP_UP)
/Zynq Section/Peripherals/LED_0: R129.2, U31.47 (LED_0)
/Zynq Section/Peripherals/LED_1: R132.2, U31.46 (LED_1)
/Zynq Section/Peripherals/SH: C392.2, R148.1, USB2.3, USB2.4, USB2.25
/Zynq Section/Peripherals/TD_M_A: J1.1 (TD+), U31.2 (TD_M_A)
/Zynq Section/Peripherals/TD_P_A: J1.2 (TD-), U31.1 (TD_P_A)
/Zynq Section/Peripherals/TD_P_B: J1.3 (RD+), J1.6 (RD-), U31.4 (TD_P_B), U31.5 (TD_M_B)
E_XI: C385.2, U31.15 (X_I), Y2.1; also elsewhere on the board
FAN_TACH: J11.3; also elsewhere on the board
GEM_RST: U31.43 (RESET_N); also elsewhere on the board
GEM_RXC: U31.32 (RX_CLK); also elsewhere on the board
GEM_RXD0: R125.2, R141.2, R142.2; also elsewhere on the board
GEM_RXD1: R126.2, R143.2, R144.2; also elsewhere on the board
GEM_RXD2: R127.2; also elsewhere on the board
GEM_RXD3: R128.2; also elsewhere on the board
GEM_RX_CTL: U31.38 (RX_CTRL); also elsewhere on the board
GEM_TXC: U31.29 (GTX_CLK); also elsewhere on the board
GEM_TXD0: R133.2; also elsewhere on the board
GEM_TXD1: R134.2; also elsewhere on the board
GEM_TXD2: R136.2; also elsewhere on the board
GEM_TXD3: R139.2; also elsewhere on the board
GEM_TX_CTL: U31.37 (TX_CTRL); also elsewhere on the board
GND: C341.1, C342.1, C343.1, C344.1, C345.1, C346.1, C347.1, C348.1, C349.1, C350.1, C351.1, C352.1, C353.2, C354.1, C355.1, C356.1, C357.1, C358.1, C359.1, C360.2, C361.1, C362.2, C363.1, C364.1, C365.1, C366.1, C367.1, C368.2, C369.2, C370.2, C371.1, C372.1, C373.1, C374.1, C375.1, C376.1, C377.1, C378.1, C379.1, C380.2, C381.2, C382.2, C383.2, C384.2, C385.1, C386.2, C387.2, C388.2, C389.2, C390.2, C391.1, C392.1, C393.2, C394.2, C395.1, C396.1, C397.2, C398.1, C399.1, C400.1, C401.1, C402.2, C403.2, C404.1, C405.1, C406.2, C407.2, C408.1, C409.1, C410.2, C411.2, C504.2, Card1.6 (VSS), Card1.10 (GND), Card1.11 (GND), Card1.12 (GND), Card1.13 (GND), J1.8 (CHSGND), J1.10, J1.11, J1.SH1, J1.SH2, J3.4 (GND), J10.1, J10.3, J10.5, J10.7, J10.9, J10.11, J10.13, J11.1, R124.1, R135.2, R137.1, R138.2, R142.1, R144.1, R146.1, R148.2, R152.2, R155.2, R158.2, R161.2, U28.2 (GND), U28.11 (GND), U28.24 (SEL), U28.25 (EP), U29.10 (VSS), U30.A6 (VSS), U30.C4 (VSSQ), U30.E7 (VSS), U30.G5 (VSS), U30.H10 (VSS), U30.J5 (VSS), U30.K8 (VSS), U30.N2 (VSSQ), U30.N5 (VSSQ), U30.P4 (VSSQ), U31.49 (GND), U32.2 (GND), U32.25 (GND), U34.3 (GND), U34.8 (GND), U35.12 (GND), U36.11 (GND), U37.1 (GND), U38.11 (TEST), U38.12 (PRTPWR1/BC_EN1), U38.13 (OCS_N1), U38.16 (PRTPWR2/BC_EN2), U38.17 (OCS_N2), U38.22 (SDA/SMBDATA/NON_REM1), U38.24 (SCL/SMBCLK/CFG_SEL0), U38.25 (HS_IND/CFG_SEL1), U38.28 (SUSP_IND/LOCAL_PWR/NON_REM0), U38.37 (VSS), U53.12 (GND), USB2.A1 (GND), USB2.A12 (GND), USB2.B1 (GND), USB2.B12 (GND), Y1.2 (G), Y1.4 (G), Y2.2 (G), Y2.4 (G), Y3.2 (G), Y3.4 (G); also elsewhere on the board
I2C0_SCL: U35.22 (SCL); also elsewhere on the board
I2C0_SDA: U35.23 (SDA); also elsewhere on the board
I2C1_SCL: R156.2, U37.3 (SCL1), U53.22 (SCL); also elsewhere on the board
I2C1_SDA: R159.2, U37.4 (SDA1), U53.23 (SDA); also elsewhere on the board
I2C_SCL1_0: R199.2, U53.5 (SC0); also elsewhere on the board
I2C_SCL1_1: U53.7 (SC1); also elsewhere on the board
I2C_SCL1_2: U53.9 (SC2); also elsewhere on the board
I2C_SCL1_3: U53.11 (SC3); also elsewhere on the board
I2C_SCL1_4: U53.14 (SC4); also elsewhere on the board
I2C_SCL1_5: U53.16 (SC5); also elsewhere on the board
I2C_SCL1_6: U53.18 (SC6); also elsewhere on the board
I2C_SCL1_7: U53.20 (SC7); also elsewhere on the board
I2C_SCL_0: R149.2, U35.5 (SC0); also elsewhere on the board
I2C_SCL_1: U35.7 (SC1); also elsewhere on the board
I2C_SCL_2: U35.9 (SC2), U36.3 (A2)
I2C_SCL_2_T: U36.18 (B2); also elsewhere on the board
I2C_SCL_3: U35.11 (SC3); also elsewhere on the board
I2C_SCL_4: U35.14 (SC4); also elsewhere on the board
I2C_SCL_5: U35.16 (SC5); also elsewhere on the board
I2C_SCL_6: U35.18 (SC6); also elsewhere on the board
I2C_SCL_7: U35.20 (SC7); also elsewhere on the board
I2C_SDA1_0: R200.2, U53.4 (SD0); also elsewhere on the board
I2C_SDA1_1: U53.6 (SD1); also elsewhere on the board
I2C_SDA1_2: U53.8 (SD2); also elsewhere on the board
I2C_SDA1_3: U53.10 (SD3); also elsewhere on the board
I2C_SDA1_4: U53.13 (SD4); also elsewhere on the board
I2C_SDA1_5: U53.15 (SD5); also elsewhere on the board
I2C_SDA1_6: U53.17 (SD6); also elsewhere on the board
I2C_SDA1_7: U53.19 (SD7); also elsewhere on the board
I2C_SDA_0: R150.2, U35.4 (SD0); also elsewhere on the board
I2C_SDA_1: U35.6 (SD1); also elsewhere on the board
I2C_SDA_2: U35.8 (SD2), U36.1 (A1)
I2C_SDA_2_T: U36.20 (B1); also elsewhere on the board
I2C_SDA_3: U35.10 (SD3); also elsewhere on the board
I2C_SDA_4: U35.13 (SD4); also elsewhere on the board
I2C_SDA_5: U35.15 (SD5); also elsewhere on the board
I2C_SDA_6: U35.17 (SD6); also elsewhere on the board
I2C_SDA_7: U35.19 (SD7); also elsewhere on the board
MDIO_MDC: U31.16 (MDC); also elsewhere on the board
MDIO_MDIO: R131.2, U31.17 (MDIO); also elsewhere on the board
unnamed: C371.2, J1.5
unnamed: C374.2, J1.4
unnamed: Card1.5 (CLK(SCLK)), R110.2
unnamed: FB9.2, U38.5 (VDDA33), U38.10 (VDDA33), U38.29 (VDDA33), U38.36 (VDDA33)
unnamed: J1.9, R129.1
unnamed: J1.12, R132.1
unnamed: J3.3 (D+), U34.2 (D1-)
unnamed: J3.2 (D-), U34.1 (D1+)
unnamed: J3.1 (VBUS), R147.1
unnamed: J6.1, R160.2, U37.5 (SDA2)
unnamed: J6.2, R157.2, U37.6 (SCL2)
unnamed: J11.4, R162.2
unnamed: R110.1, U28.19 (CLKB0)
unnamed: R112.1, U29.16 (C)
unnamed: R113.2, U29.3 (~RESET)
unnamed: R122.1, U30.M6 (CLK)
unnamed: C361.2, U30.C2 (VDDI)
unnamed: R124.2, U31.12 (RBIAS)
unnamed: R128.1, U31.33 (RX_D0)
unnamed: R127.1, U31.34 (RX_D1)
unnamed: R126.1, U31.35 (RX_D2)
unnamed: R125.1, U31.36 (RX_D3)
unnamed: R133.1, U31.28 (TX_D0)
unnamed: R134.1, U31.27 (TX_D1)
unnamed: R136.1, U31.26 (TX_D2)
unnamed: R139.1, U31.25 (TX_D3)
unnamed: C375.2, U31.14 (X_O), Y2.3
unnamed: U32.3 (D+), U34.5 (D2-)
unnamed: U32.4 (D-), U34.4 (D2+)
unnamed: R146.2, R147.2, U32.8 (VBUS)
unnamed: R145.2, U32.9 (~RST)
unnamed: R137.2, U33.24 (RBIAS)
unnamed: R130.2, U33.27 (RESETB)
unnamed: R140.2, U33.22 (VBUS)
unnamed: C390.1, U33.20 (VDD33)
unnamed: C373.2, U33.25 (XO), Y1.1
unnamed: R151.2, U35.3 (~RESET)
unnamed: R152.1, U36.10 (OE)
unnamed: C411.1, U38.14 (CRFILT)
unnamed: C410.1, U38.34 (PLLFILT)
unnamed: R161.1, U38.35 (RBIAS)
unnamed: R158.1, U38.26 (RESET_N)
unnamed: R153.1, R155.1, U38.27 (VBUS_DET)
unnamed: C408.2, U38.33 (XTALIN/CLKIN), Y3.1
unnamed: C409.2, U38.32 (XTALOUT), Y3.3
unnamed: R198.2, U53.3 (~RESET)
PS_JTAG_TCK: J10.6; also elsewhere on the board
PS_JTAG_TDI: J10.10; also elsewhere on the board
PS_JTAG_TDO: J10.8; also elsewhere on the board
PS_JTAG_TMS: J10.4; also elsewhere on the board
PS_SRST_B: J10.12; also elsewhere on the board
QSPI_IO0: U29.15 (DQ0); also elsewhere on the board
QSPI_IO1: U29.8 (DQ1); also elsewhere on the board
QSPI_IO2: R115.2, U29.9 (~W/DQ2); also elsewhere on the board
QSPI_IO3: R111.2, U29.1 (DQ3/~HOLD); also elsewhere on the board
QSPI_SCLK: R112.2; also elsewhere on the board
QSPI_SS: R114.2, U29.7 (~S); also elsewhere on the board
SD0_CLK: R122.2; also elsewhere on the board
SD0_CMD: R123.2, U30.M5 (CMD); also elsewhere on the board
SD0_D0: R116.2, U30.A3 (DAT0); also elsewhere on the board
SD0_D1: U30.A4 (DAT1); also elsewhere on the board
SD0_D2: U30.A5 (DAT2); also elsewhere on the board
SD0_D3: U30.B2 (DAT3); also elsewhere on the board
SD0_D4: U30.B3 (DAT4); also elsewhere on the board
SD0_D5: U30.B4 (DAT5); also elsewhere on the board
SD0_D6: U30.B5 (DAT6); also elsewhere on the board
SD0_D7: U30.B6 (DAT7); also elsewhere on the board
SD0_RST: U30.K5 (RSTN); also elsewhere on the board
SD1_CD: Card1.9 (CD); also elsewhere on the board
SD1_CLK: U28.9 (CLKA); also elsewhere on the board
SD1_CMD: U28.4 (CMDA); also elsewhere on the board
SD1_D0: U28.6 (DAT0A); also elsewhere on the board
SD1_D1: U28.7 (DAT1A); also elsewhere on the board
SD1_D2: U28.1 (DAT2A); also elsewhere on the board
SD1_D3: U28.3 (DAT3A); also elsewhere on the board
UART0_RX: U32.20 (RXD); also elsewhere on the board
UART0_TX: U32.21 (TXD); also elsewhere on the board
USB2_CLK: U33.1 (CLKOUT); also elsewhere on the board
USB2_D0: U33.3 (DATA0); also elsewhere on the board
USB2_D1: U33.4 (DATA1); also elsewhere on the board
USB2_D2: U33.5 (DATA2); also elsewhere on the board
USB2_D3: U33.6 (DATA3); also elsewhere on the board
USB2_D4: U33.7 (DATA4); also elsewhere on the board
USB2_D5: U33.9 (DATA5); also elsewhere on the board
USB2_D6: U33.10 (DATA6); also elsewhere on the board
USB2_D7: U33.13 (DATA7); also elsewhere on the board
USB2_DIR: U33.31 (DIR); also elsewhere on the board
USB2_NXT: U33.2 (NXT); also elsewhere on the board
USB2_STP: U33.29 (STP); also elsewhere on the board
USB3_VBUS: R153.2; also elsewhere on the board
USBDM_DN1: U38.1 (USBDM_DN1/PRT_DIS_M1), USB2.A7 (Dn1), USB2.B7 (Dn2)
USBDM_DN2: U38.3 (USBDM_DN2/PRT_DIS_M2); also elsewhere on the board
USBDP_DN1: U38.2 (USBDP_DN1/PRT_DIS_P1), USB2.A6 (Dp1), USB2.B6 (Dp2)
USBDP_DN2: U38.4 (USBDP_DN2/PRT_DIS_P2); also elsewhere on the board
USB_REFCLK: C372.2, U33.26 (REFCLK), Y1.3; also elsewhere on the board
VBUS: R140.1, USB2.A4 (VBUS), USB2.A9 (VBUS), USB2.B4 (VBUS), USB2.B9 (VBUS); also elsewhere on the board

Notes on the sheet:
I2C_MUX
VDD18
VDD1P0
USB Phy
QSPIO
Section 04c : Peripherals
0x77
VDDIO
VCC
SD CARD
Ethernet
UART
eMMC
I2C_TRANSLATOR
JTAG Header + Fan
VCCB0+B1
PULL-UPS
VCCA

Schematic: 04b_Zynq_DDR4.kicad_sch

Parts:
C252, C253, C254, C255, C256, C257, C258, C259, C260, C261, C262, C263, C264, C265, C266, C267, C268, C269, C270, C271, C272, C273, C274, C275, C276, C277, C278, C279, C280, C281, C282, C283, C284, C285, C286, C287, C288, C289, C290, C291, C292, C293, C294, C295, C296, C297, C298, C299, C300, C301, C302, C303, C304, C305, C306, C307, C308, C309, C310, C311, C312, C313, C314, C315, C316, C317, C318, C319, C320, C321, C322, C323, C324, C325, C326, C327, C328, C329, C330, C331, C332, C333, C334, C335, C336, C337, C338, C339, C340: 0.1uF; C_0402_1005Metric
R104, R105: 1kΩ; R_0402_1005Metric
R106, R107, R108, R109: 240Ω; R_0402_1005Metric
U_RAM1, U_RAM2, U_RAM3, U_RAM4: MT40A512M16LY-075:E; FBGA-96_L13.5-W7.5-R16-C6-P0.80-TL; MPN MT40A512M16LY-075:E; LCSC Part C598779

Connections:
+1V2: C256.2, C257.2, C258.2, C259.2, C260.2, C261.2, C262.2, C263.2, C264.2, C265.2, C266.2, C267.2, C268.2, C269.2, C270.2, C271.2, C272.2, C273.2, C274.2, C275.2, C280.1, C281.1, C282.1, C283.1, C284.1, C285.1, C286.1, C287.1, C288.1, C289.1, C290.1, C291.1, C292.1, C293.1, C294.1, C295.1, C296.1, C297.1, C298.1, C299.1, C300.2, C301.2, C302.2, C303.2, C304.2, C305.2, C306.2, C307.2, C308.2, C309.2, C310.2, C311.2, C312.2, C313.2, C314.2, C315.2, C316.2, C317.2, C318.2, C319.2, C320.1, C321.1, C322.1, C323.1, C324.1, C325.1, C326.1, C327.1, C328.1, C329.1, C330.1, C331.1, C332.1, C333.1, C334.1, C335.1, C336.1, C337.1, C338.1, C339.1, R104.2, U_RAM1.A1 (VDDQ), U_RAM1.A9 (VDDQ), U_RAM1.B3 (VDD), U_RAM1.B9 (VDD), U_RAM1.C1 (VDDQ), U_RAM1.D1 (VDD), U_RAM1.D9 (VDDQ), U_RAM1.F2 (VDDQ), U_RAM1.F8 (VDDQ), U_RAM1.G1 (VDDQ), U_RAM1.G7 (VDD), U_RAM1.G9 (VDDQ), U_RAM1.J1 (VDD), U_RAM1.J2 (VDDQ), U_RAM1.J8 (VDDQ), U_RAM1.J9 (VDD), U_RAM1.L1 (VDD), U_RAM1.L9 (VDD), U_RAM1.R1 (VDD), U_RAM1.T9 (VDD), U_RAM2.A1 (VDDQ), U_RAM2.A9 (VDDQ), U_RAM2.B3 (VDD), U_RAM2.B9 (VDD), U_RAM2.C1 (VDDQ), U_RAM2.D1 (VDD), U_RAM2.D9 (VDDQ), U_RAM2.F2 (VDDQ), U_RAM2.F8 (VDDQ), U_RAM2.G1 (VDDQ), U_RAM2.G7 (VDD), U_RAM2.G9 (VDDQ), U_RAM2.J1 (VDD), U_RAM2.J2 (VDDQ), U_RAM2.J8 (VDDQ), U_RAM2.J9 (VDD), U_RAM2.L1 (VDD), U_RAM2.L9 (VDD), U_RAM2.R1 (VDD), U_RAM2.T9 (VDD), U_RAM3.A1 (VDDQ), U_RAM3.A9 (VDDQ), U_RAM3.B3 (VDD), U_RAM3.B9 (VDD), U_RAM3.C1 (VDDQ), U_RAM3.D1 (VDD), U_RAM3.D9 (VDDQ), U_RAM3.F2 (VDDQ), U_RAM3.F8 (VDDQ), U_RAM3.G1 (VDDQ), U_RAM3.G7 (VDD), U_RAM3.G9 (VDDQ), U_RAM3.J1 (VDD), U_RAM3.J2 (VDDQ), U_RAM3.J8 (VDDQ), U_RAM3.J9 (VDD), U_RAM3.L1 (VDD), U_RAM3.L9 (VDD), U_RAM3.R1 (VDD), U_RAM3.T9 (VDD), U_RAM4.A1 (VDDQ), U_RAM4.A9 (VDDQ), U_RAM4.B3 (VDD), U_RAM4.B9 (VDD), U_RAM4.C1 (VDDQ), U_RAM4.D1 (VDD), U_RAM4.D9 (VDDQ), U_RAM4.F2 (VDDQ), U_RAM4.F8 (VDDQ), U_RAM4.G1 (VDDQ), U_RAM4.G7 (VDD), U_RAM4.G9 (VDDQ), U_RAM4.J1 (VDD), U_RAM4.J2 (VDDQ), U_RAM4.J8 (VDDQ), U_RAM4.J9 (VDD), U_RAM4.L1 (VDD), U_RAM4.L9 (VDD), U_RAM4.R1 (VDD), U_RAM4.T9 (VDD); also elsewhere on the board
+2V5: C252.2, C253.2, C254.2, C255.2, C276.1, C277.1, C278.1, C279.1, U_RAM1.B1 (VPP), U_RAM1.R9 (VPP), U_RAM2.B1 (VPP), U_RAM2.R9 (VPP), U_RAM3.B1 (VPP), U_RAM3.R9 (VPP), U_RAM4.B1 (VPP), U_RAM4.R9 (VPP); also elsewhere on the board
GND: C252.1, C253.1, C254.1, C255.1, C256.1, C257.1, C258.1, C259.1, C260.1, C261.1, C262.1, C263.1, C264.1, C265.1, C266.1, C267.1, C268.1, C269.1, C270.1, C271.1, C272.1, C273.1, C274.1, C275.1, C276.2, C277.2, C278.2, C279.2, C280.2, C281.2, C282.2, C283.2, C284.2, C285.2, C286.2, C287.2, C288.2, C289.2, C290.2, C291.2, C292.2, C293.2, C294.2, C295.2, C296.2, C297.2, C298.2, C299.2, C300.1, C301.1, C302.1, C303.1, C304.1, C305.1, C306.1, C307.1, C308.1, C309.1, C310.1, C311.1, C312.1, C313.1, C314.1, C315.1, C316.1, C317.1, C318.1, C319.1, C320.2, C321.2, C322.2, C323.2, C324.2, C325.2, C326.2, C327.2, C328.2, C329.2, C330.2, C331.2, C332.2, C333.2, C334.2, C335.2, C336.2, C337.2, C338.2, C339.2, C340.2, R105.2, R106.2, R107.2, R108.2, R109.2, U_RAM1.A2 (VSSQ), U_RAM1.A8 (VSSQ), U_RAM1.B2 (VSS), U_RAM1.C9 (VSSQ), U_RAM1.D2 (VSSQ), U_RAM1.D8 (VSSQ), U_RAM1.E1 (VSS), U_RAM1.E3 (VSSQ), U_RAM1.E8 (VSSQ), U_RAM1.E9 (VSS), U_RAM1.F1 (VSSQ), U_RAM1.G8 (VSS), U_RAM1.H1 (VSSQ), U_RAM1.H9 (VSSQ), U_RAM1.K1 (VSS), U_RAM1.K9 (VSS), U_RAM1.M9 (VSS), U_RAM1.N1 (VSS), U_RAM1.T1 (VSS), U_RAM2.A2 (VSSQ), U_RAM2.A8 (VSSQ), U_RAM2.B2 (VSS), U_RAM2.C9 (VSSQ), U_RAM2.D2 (VSSQ), U_RAM2.D8 (VSSQ), U_RAM2.E1 (VSS), U_RAM2.E3 (VSSQ), U_RAM2.E8 (VSSQ), U_RAM2.E9 (VSS), U_RAM2.F1 (VSSQ), U_RAM2.G8 (VSS), U_RAM2.H1 (VSSQ), U_RAM2.H9 (VSSQ), U_RAM2.K1 (VSS), U_RAM2.K9 (VSS), U_RAM2.M9 (VSS), U_RAM2.N1 (VSS), U_RAM2.T1 (VSS), U_RAM3.A2 (VSSQ), U_RAM3.A8 (VSSQ), U_RAM3.B2 (VSS), U_RAM3.C9 (VSSQ), U_RAM3.D2 (VSSQ), U_RAM3.D8 (VSSQ), U_RAM3.E1 (VSS), U_RAM3.E3 (VSSQ), U_RAM3.E8 (VSSQ), U_RAM3.E9 (VSS), U_RAM3.F1 (VSSQ), U_RAM3.G8 (VSS), U_RAM3.H1 (VSSQ), U_RAM3.H9 (VSSQ), U_RAM3.K1 (VSS), U_RAM3.K9 (VSS), U_RAM3.M9 (VSS), U_RAM3.N1 (VSS), U_RAM3.T1 (VSS), U_RAM4.A2 (VSSQ), U_RAM4.A8 (VSSQ), U_RAM4.B2 (VSS), U_RAM4.C9 (VSSQ), U_RAM4.D2 (VSSQ), U_RAM4.D8 (VSSQ), U_RAM4.E1 (VSS), U_RAM4.E3 (VSSQ), U_RAM4.E8 (VSSQ), U_RAM4.E9 (VSS), U_RAM4.F1 (VSSQ), U_RAM4.G8 (VSS), U_RAM4.H1 (VSSQ), U_RAM4.H9 (VSSQ), U_RAM4.K1 (VSS), U_RAM4.K9 (VSS), U_RAM4.M9 (VSS), U_RAM4.N1 (VSS), U_RAM4.T1 (VSS); also elsewhere on the board
unnamed: R106.1, U_RAM1.F9 (ZQ)
unnamed: R107.1, U_RAM2.F9 (ZQ)
unnamed: R108.1, U_RAM3.F9 (ZQ)
unnamed: R109.1, U_RAM4.F9 (ZQ)
PS_DDR_A0: U_RAM1.P3 (A0), U_RAM2.P3 (A0), U_RAM3.P3 (A0), U_RAM4.P3 (A0); also elsewhere on the board
PS_DDR_A1: U_RAM1.P7 (A1), U_RAM2.P7 (A1), U_RAM3.P7 (A1), U_RAM4.P7 (A1); also elsewhere on the board
PS_DDR_A2: U_RAM1.R3 (A2), U_RAM2.R3 (A2), U_RAM3.R3 (A2), U_RAM4.R3 (A2); also elsewhere on the board
PS_DDR_A3: U_RAM1.N7 (A3), U_RAM2.N7 (A3), U_RAM3.N7 (A3), U_RAM4.N7 (A3); also elsewhere on the board
PS_DDR_A4: U_RAM1.N3 (A4), U_RAM2.N3 (A4), U_RAM3.N3 (A4), U_RAM4.N3 (A4); also elsewhere on the board
PS_DDR_A5: U_RAM1.P8 (A5), U_RAM2.P8 (A5), U_RAM3.P8 (A5), U_RAM4.P8 (A5); also elsewhere on the board
PS_DDR_A6: U_RAM1.P2 (A6), U_RAM2.P2 (A6), U_RAM3.P2 (A6), U_RAM4.P2 (A6); also elsewhere on the board
PS_DDR_A7: U_RAM1.R8 (A7), U_RAM2.R8 (A7), U_RAM3.R8 (A7), U_RAM4.R8 (A7); also elsewhere on the board
PS_DDR_A8: U_RAM1.R2 (A8), U_RAM2.R2 (A8), U_RAM3.R2 (A8), U_RAM4.R2 (A8); also elsewhere on the board
PS_DDR_A9: U_RAM1.R7 (A9), U_RAM2.R7 (A9), U_RAM3.R7 (A9), U_RAM4.R7 (A9); also elsewhere on the board
PS_DDR_A10: U_RAM1.M3 (A10/AP), U_RAM2.M3 (A10/AP), U_RAM3.M3 (A10/AP), U_RAM4.M3 (A10/AP); also elsewhere on the board
PS_DDR_A11: U_RAM1.T2 (A11), U_RAM2.T2 (A11), U_RAM3.T2 (A11), U_RAM4.T2 (A11); also elsewhere on the board
PS_DDR_A12: U_RAM1.M7 (A12/BC_n), U_RAM2.M7 (A12/BC_n), U_RAM3.M7 (A12/BC_n), U_RAM4.M7 (A12/BC_n); also elsewhere on the board
PS_DDR_A13: U_RAM1.T8 (A13), U_RAM2.T8 (A13), U_RAM3.T8 (A13), U_RAM4.T8 (A13); also elsewhere on the board
PS_DDR_A14: U_RAM1.L2 (WE_n/A14), U_RAM2.L2 (WE_n/A14), U_RAM3.L2 (WE_n/A14), U_RAM4.L2 (WE_n/A14); also elsewhere on the board
PS_DDR_A15: U_RAM1.M8 (CAS-n/A15), U_RAM2.M8 (CAS-n/A15), U_RAM3.M8 (CAS-n/A15), U_RAM4.M8 (CAS-n/A15); also elsewhere on the board
PS_DDR_A16: U_RAM1.L8 (RAS_n/A16), U_RAM2.L8 (RAS_n/A16), U_RAM3.L8 (RAS_n/A16), U_RAM4.L8 (RAS_n/A16); also elsewhere on the board
PS_DDR_ACT_N: U_RAM1.L3 (ACT_n), U_RAM2.L3 (ACT_n), U_RAM3.L3 (ACT_n), U_RAM4.L3 (ACT_n); also elsewhere on the board
PS_DDR_ALERT_N: U_RAM1.P9 (ALERT_n), U_RAM2.P9 (ALERT_n), U_RAM3.P9 (ALERT_n), U_RAM4.P9 (ALERT_n); also elsewhere on the board
PS_DDR_BA0: U_RAM1.N2 (BA0), U_RAM2.N2 (BA0), U_RAM3.N2 (BA0), U_RAM4.N2 (BA0); also elsewhere on the board
PS_DDR_BA1: U_RAM1.N8 (BA1), U_RAM2.N8 (BA1), U_RAM3.N8 (BA1), U_RAM4.N8 (BA1); also elsewhere on the board
PS_DDR_BG0: U_RAM1.M2 (BG0), U_RAM2.M2 (BG0), U_RAM3.M2 (BG0), U_RAM4.M2 (BG0); also elsewhere on the board
PS_DDR_CK0: U_RAM1.K7 (CK_t), U_RAM2.K7 (CK_t), U_RAM3.K7 (CK_t), U_RAM4.K7 (CK_t); also elsewhere on the board
PS_DDR_CKE0: U_RAM1.K2 (CKE), U_RAM2.K2 (CKE), U_RAM3.K2 (CKE), U_RAM4.K2 (CKE); also elsewhere on the board
PS_DDR_CK_N0: U_RAM1.K8 (CK_c), U_RAM2.K8 (CK_c), U_RAM3.K8 (CK_c), U_RAM4.K8 (CK_c); also elsewhere on the board
PS_DDR_CS_N0: U_RAM1.L7 (CS_n), U_RAM2.L7 (CS_n), U_RAM3.L7 (CS_n), U_RAM4.L7 (CS_n); also elsewhere on the board
PS_DDR_DM0: U_RAM1.E7 (NF/LDM_n/LDBI_n); also elsewhere on the board
PS_DDR_DM1: U_RAM1.E2 (NF/UDM_n/UDBI_n); also elsewhere on the board
PS_DDR_DM2: U_RAM2.E7 (NF/LDM_n/LDBI_n); also elsewhere on the board
PS_DDR_DM3: U_RAM2.E2 (NF/UDM_n/UDBI_n); also elsewhere on the board
PS_DDR_DM4: U_RAM3.E7 (NF/LDM_n/LDBI_n); also elsewhere on the board
PS_DDR_DM5: U_RAM3.E2 (NF/UDM_n/UDBI_n); also elsewhere on the board
PS_DDR_DM6: U_RAM4.E7 (NF/LDM_n/LDBI_n); also elsewhere on the board
PS_DDR_DM7: U_RAM4.E2 (NF/UDM_n/UDBI_n); also elsewhere on the board
PS_DDR_DQ0: U_RAM1.G2 (DQ0); also elsewhere on the board
PS_DDR_DQ1: U_RAM1.F7 (DQ1); also elsewhere on the board
PS_DDR_DQ2: U_RAM1.H3 (DQ2); also elsewhere on the board
PS_DDR_DQ3: U_RAM1.H7 (DQ3); also elsewhere on the board
PS_DDR_DQ4: U_RAM1.H2 (DQ4); also elsewhere on the board
PS_DDR_DQ5: U_RAM1.H8 (DQ5); also elsewhere on the board
PS_DDR_DQ6: U_RAM1.J3 (DQ6); also elsewhere on the board
PS_DDR_DQ7: U_RAM1.J7 (DQ7); also elsewhere on the board
PS_DDR_DQ8: U_RAM1.A3 (DQ8); also elsewhere on the board
PS_DDR_DQ9: U_RAM1.B8 (DQ9); also elsewhere on the board
PS_DDR_DQ10: U_RAM1.C3 (DQ10); also elsewhere on the board
PS_DDR_DQ11: U_RAM1.C7 (DQ11); also elsewhere on the board
PS_DDR_DQ12: U_RAM1.C2 (DQ12); also elsewhere on the board
PS_DDR_DQ13: U_RAM1.C8 (DQ13); also elsewhere on the board
PS_DDR_DQ14: U_RAM1.D3 (DQ14); also elsewhere on the board
PS_DDR_DQ15: U_RAM1.D7 (DQ15); also elsewhere on the board
PS_DDR_DQ16: U_RAM2.G2 (DQ0); also elsewhere on the board
PS_DDR_DQ17: U_RAM2.F7 (DQ1); also elsewhere on the board
PS_DDR_DQ18: U_RAM2.H3 (DQ2); also elsewhere on the board
PS_DDR_DQ19: U_RAM2.H7 (DQ3); also elsewhere on the board
PS_DDR_DQ20: U_RAM2.H2 (DQ4); also elsewhere on the board
PS_DDR_DQ21: U_RAM2.H8 (DQ5); also elsewhere on the board
PS_DDR_DQ22: U_RAM2.J3 (DQ6); also elsewhere on the board
PS_DDR_DQ23: U_RAM2.J7 (DQ7); also elsewhere on the board
PS_DDR_DQ24: U_RAM2.A3 (DQ8); also elsewhere on the board
PS_DDR_DQ25: U_RAM2.B8 (DQ9); also elsewhere on the board
PS_DDR_DQ26: U_RAM2.C3 (DQ10); also elsewhere on the board
PS_DDR_DQ27: U_RAM2.C7 (DQ11); also elsewhere on the board
PS_DDR_DQ28: U_RAM2.C2 (DQ12); also elsewhere on the board
PS_DDR_DQ29: U_RAM2.C8 (DQ13); also elsewhere on the board
PS_DDR_DQ30: U_RAM2.D3 (DQ14); also elsewhere on the board
PS_DDR_DQ31: U_RAM2.D7 (DQ15); also elsewhere on the board
PS_DDR_DQ32: U_RAM3.G2 (DQ0); also elsewhere on the board
PS_DDR_DQ33: U_RAM3.F7 (DQ1); also elsewhere on the board
PS_DDR_DQ34: U_RAM3.H3 (DQ2); also elsewhere on the board
PS_DDR_DQ35: U_RAM3.H7 (DQ3); also elsewhere on the board
PS_DDR_DQ36: U_RAM3.H2 (DQ4); also elsewhere on the board
PS_DDR_DQ37: U_RAM3.H8 (DQ5); also elsewhere on the board
PS_DDR_DQ38: U_RAM3.J3 (DQ6); also elsewhere on the board
PS_DDR_DQ39: U_RAM3.J7 (DQ7); also elsewhere on the board
PS_DDR_DQ40: U_RAM3.A3 (DQ8); also elsewhere on the board
PS_DDR_DQ41: U_RAM3.B8 (DQ9); also elsewhere on the board
PS_DDR_DQ42: U_RAM3.C3 (DQ10); also elsewhere on the board
PS_DDR_DQ43: U_RAM3.C7 (DQ11); also elsewhere on the board
PS_DDR_DQ44: U_RAM3.C2 (DQ12); also elsewhere on the board
PS_DDR_DQ45: U_RAM3.C8 (DQ13); also elsewhere on the board
PS_DDR_DQ46: U_RAM3.D3 (DQ14); also elsewhere on the board
PS_DDR_DQ47: U_RAM3.D7 (DQ15); also elsewhere on the board
PS_DDR_DQ48: U_RAM4.G2 (DQ0); also elsewhere on the board
PS_DDR_DQ49: U_RAM4.F7 (DQ1); also elsewhere on the board
PS_DDR_DQ50: U_RAM4.H3 (DQ2); also elsewhere on the board
PS_DDR_DQ51: U_RAM4.H7 (DQ3); also elsewhere on the board
PS_DDR_DQ52: U_RAM4.H2 (DQ4); also elsewhere on the board
PS_DDR_DQ53: U_RAM4.H8 (DQ5); also elsewhere on the board
PS_DDR_DQ54: U_RAM4.J3 (DQ6); also elsewhere on the board
PS_DDR_DQ55: U_RAM4.J7 (DQ7); also elsewhere on the board
PS_DDR_DQ56: U_RAM4.A3 (DQ8); also elsewhere on the board
PS_DDR_DQ57: U_RAM4.B8 (DQ9); also elsewhere on the board
PS_DDR_DQ58: U_RAM4.C3 (DQ10); also elsewhere on the board
PS_DDR_DQ59: U_RAM4.C7 (DQ11); also elsewhere on the board
PS_DDR_DQ60: U_RAM4.C2 (DQ12); also elsewhere on the board
PS_DDR_DQ61: U_RAM4.C8 (DQ13); also elsewhere on the board
PS_DDR_DQ62: U_RAM4.D3 (DQ14); also elsewhere on the board
PS_DDR_DQ63: U_RAM4.D7 (DQ15); also elsewhere on the board
PS_DDR_DQS_N0: U_RAM1.F3 (LDQS_c); also elsewhere on the board
PS_DDR_DQS_N1: U_RAM1.A7 (UDQS_c); also elsewhere on the board
PS_DDR_DQS_N2: U_RAM2.F3 (LDQS_c); also elsewhere on the board
PS_DDR_DQS_N3: U_RAM2.A7 (UDQS_c); also elsewhere on the board
PS_DDR_DQS_N4: U_RAM3.A7 (UDQS_c); also elsewhere on the board
PS_DDR_DQS_N5: U_RAM3.F3 (LDQS_c); also elsewhere on the board
PS_DDR_DQS_N6: U_RAM4.F3 (LDQS_c); also elsewhere on the board
PS_DDR_DQS_N7: U_RAM4.B7 (UDQS_t); also elsewhere on the board
PS_DDR_DQS_P0: U_RAM1.G3 (LDQS_t); also elsewhere on the board
PS_DDR_DQS_P1: U_RAM1.B7 (UDQS_t); also elsewhere on the board
PS_DDR_DQS_P2: U_RAM2.G3 (LDQS_t); also elsewhere on the board
PS_DDR_DQS_P3: U_RAM2.B7 (UDQS_t); also elsewhere on the board
PS_DDR_DQS_P4: U_RAM3.G3 (LDQS_t); also elsewhere on the board
PS_DDR_DQS_P5: U_RAM3.B7 (UDQS_t); also elsewhere on the board
PS_DDR_DQS_P6: U_RAM4.G3 (LDQS_t); also elsewhere on the board
PS_DDR_DQS_P7: U_RAM4.A7 (UDQS_c); also elsewhere on the board
PS_DDR_ODT0: U_RAM1.K3 (ODT), U_RAM2.K3 (ODT), U_RAM3.K3 (ODT), U_RAM4.K3 (ODT); also elsewhere on the board
PS_DDR_PARITY: U_RAM1.T3 (PAR), U_RAM2.T3 (PAR), U_RAM3.T3 (PAR), U_RAM4.T3 (PAR); also elsewhere on the board
PS_DDR_RAM_RST_N: U_RAM1.P1 (RESET_n), U_RAM2.P1 (RESET_n), U_RAM3.P1 (RESET_n), U_RAM4.P1 (RESET_n); also elsewhere on the board
VREFCA_DDR4: C340.1, R104.1, R105.1, U_RAM1.M1 (VREFCA), U_RAM2.M1 (VREFCA), U_RAM3.M1 (VREFCA), U_RAM4.M1 (VREFCA)

Notes on the sheet:
VPP
VDDQ
VDD
SECTION 04b : DDR4
DECOUPLING CAPACITORS
